# Keil uVision project freehandcmsisrtosbluepill.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: freehandcmsisrtosbluepill +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c Thread_LED.c Radio.c USBD_User_CDC_ACM_0.c RH_RF95.cpp RHSPIDriver.cpp
software components: CMSIS:CORE 5.3.0, CMSIS:RTOS:Keil RTX 4.82.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, USB:CORE 6.13.6, USB:Device 6.13.6, USB:Device:CDC 6.13.6, CMSIS Driver:SPI 2.2, CMSIS Driver:USB Device 2.1, Device:DMA 1.2, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:DBGMCU 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1
